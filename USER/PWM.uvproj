# Keil uVision project PWM.uvproj, settings and files
target PWM (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\PWM;..\FWLIB\inc;..\HARDWARE\TIMER;..\HARDWARE\HCSR04;..\HARDWARE\TIMER;..\HARDWARE\GRUB;..\HARDWARE\GRUB;..\HARDWARE\TIMER;..\HARDWARE\CAPSTAN;..\HARDWARE\TRACE;..\HARDWARE\BRAKE;..\HARDWARE\TRACE;..\HARDWARE\RFID;..\SYSTEM\uart6;..\HARDWARE\RFID;..\SYSTEM\uart6;..\HARDWARE\HCSR04_2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/HCSR04/: hcsr04.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/GRUB/: grub.c
    ../HARDWARE/CAPSTAN/: capstan.c
    ../HARDWARE/TRACE/: trace.c
    ../HARDWARE/BRAKE/: brake.c
    ../HARDWARE/RFID/: rfid.c
    ../HARDWARE/HCSR04_2/: hcsr04_2.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/uart6/: uart6.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c
